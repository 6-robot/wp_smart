/*
 * SSD1306 I2C OLED 驱动库 (修复版)
 * 适用于 ESP32-S3 + 128x64 SSD1306 OLED
 * 
 * 修复: 使用逐页发送数据，降低I2C速率，确保稳定显示
 */

#pragma once
#include <Arduino.h>
#include <Wire.h>

// ═══════════════════════════════════════════════════════════════
//  内置 ASCII 5x7 字体表 (空格 0x20 ~ 波浪号 0x7E, 共 95 个字符)
// ═══════════════════════════════════════════════════════════════
static const uint8_t FONT_5x7[][5] PROGMEM = {
  {0x00,0x00,0x00,0x00,0x00}, // 0x20 ' '
  {0x00,0x00,0x5F,0x00,0x00}, // 0x21 '!'
  {0x00,0x07,0x00,0x07,0x00}, // 0x22 '"'
  {0x14,0x7F,0x14,0x7F,0x14}, // 0x23 '#'
  {0x24,0x2A,0x7F,0x2A,0x12}, // 0x24 '$'
  {0x23,0x13,0x08,0x64,0x62}, // 0x25 '%'
  {0x36,0x49,0x55,0x22,0x50}, // 0x26 '&'
  {0x00,0x05,0x03,0x00,0x00}, // 0x27 '''
  {0x00,0x1C,0x22,0x41,0x00}, // 0x28 '('
  {0x00,0x41,0x22,0x1C,0x00}, // 0x29 ')'
  {0x14,0x08,0x3E,0x08,0x14}, // 0x2A '*'
  {0x08,0x08,0x3E,0x08,0x08}, // 0x2B '+'
  {0x00,0x50,0x30,0x00,0x00}, // 0x2C ','
  {0x08,0x08,0x08,0x08,0x08}, // 0x2D '-'
  {0x00,0x60,0x60,0x00,0x00}, // 0x2E '.'
  {0x20,0x10,0x08,0x04,0x02}, // 0x2F '/'
  {0x3E,0x51,0x49,0x45,0x3E}, // 0x30 '0'
  {0x00,0x42,0x7F,0x40,0x00}, // 0x31 '1'
  {0x42,0x61,0x51,0x49,0x46}, // 0x32 '2'
  {0x21,0x41,0x45,0x4B,0x31}, // 0x33 '3'
  {0x18,0x14,0x12,0x7F,0x10}, // 0x34 '4'
  {0x27,0x45,0x45,0x45,0x39}, // 0x35 '5'
  {0x3C,0x4A,0x49,0x49,0x30}, // 0x36 '6'
  {0x01,0x71,0x09,0x05,0x03}, // 0x37 '7'
  {0x36,0x49,0x49,0x49,0x36}, // 0x38 '8'
  {0x06,0x49,0x49,0x29,0x1E}, // 0x39 '9'
  {0x00,0x36,0x36,0x00,0x00}, // 0x3A ':'
  {0x00,0x56,0x36,0x00,0x00}, // 0x3B ';'
  {0x08,0x14,0x22,0x41,0x00}, // 0x3C '<'
  {0x14,0x14,0x14,0x14,0x14}, // 0x3D '='
  {0x00,0x41,0x22,0x14,0x08}, // 0x3E '>'
  {0x02,0x01,0x51,0x09,0x06}, // 0x3F '?'
  {0x32,0x49,0x79,0x41,0x3E}, // 0x40 '@'
  {0x7E,0x11,0x11,0x11,0x7E}, // 0x41 'A'
  {0x7F,0x49,0x49,0x49,0x36}, // 0x42 'B'
  {0x3E,0x41,0x41,0x41,0x22}, // 0x43 'C'
  {0x7F,0x41,0x41,0x22,0x1C}, // 0x44 'D'
  {0x7F,0x49,0x49,0x49,0x41}, // 0x45 'E'
  {0x7F,0x09,0x09,0x09,0x01}, // 0x46 'F'
  {0x3E,0x41,0x49,0x49,0x7A}, // 0x47 'G'
  {0x7F,0x08,0x08,0x08,0x7F}, // 0x48 'H'
  {0x00,0x41,0x7F,0x41,0x00}, // 0x49 'I'
  {0x20,0x40,0x41,0x3F,0x01}, // 0x4A 'J'
  {0x7F,0x08,0x14,0x22,0x41}, // 0x4B 'K'
  {0x7F,0x40,0x40,0x40,0x40}, // 0x4C 'L'
  {0x7F,0x02,0x0C,0x02,0x7F}, // 0x4D 'M'
  {0x7F,0x04,0x08,0x10,0x7F}, // 0x4E 'N'
  {0x3E,0x41,0x41,0x41,0x3E}, // 0x4F 'O'
  {0x7F,0x09,0x09,0x09,0x06}, // 0x50 'P'
  {0x3E,0x41,0x51,0x21,0x5E}, // 0x51 'Q'
  {0x7F,0x09,0x19,0x29,0x46}, // 0x52 'R'
  {0x46,0x49,0x49,0x49,0x31}, // 0x53 'S'
  {0x01,0x01,0x7F,0x01,0x01}, // 0x54 'T'
  {0x3F,0x40,0x40,0x40,0x3F}, // 0x55 'U'
  {0x1F,0x20,0x40,0x20,0x1F}, // 0x56 'V'
  {0x3F,0x40,0x38,0x40,0x3F}, // 0x57 'W'
  {0x63,0x14,0x08,0x14,0x63}, // 0x58 'X'
  {0x07,0x08,0x70,0x08,0x07}, // 0x59 'Y'
  {0x61,0x51,0x49,0x45,0x43}, // 0x5A 'Z'
  {0x00,0x7F,0x41,0x41,0x00}, // 0x5B '['
  {0x02,0x04,0x08,0x10,0x20}, // 0x5C '\'
  {0x00,0x41,0x41,0x7F,0x00}, // 0x5D ']'
  {0x04,0x02,0x01,0x02,0x04}, // 0x5E '^'
  {0x40,0x40,0x40,0x40,0x40}, // 0x5F '_'
  {0x00,0x01,0x02,0x04,0x00}, // 0x60 '`'
  {0x20,0x54,0x54,0x54,0x78}, // 0x61 'a'
  {0x7F,0x48,0x44,0x44,0x38}, // 0x62 'b'
  {0x38,0x44,0x44,0x44,0x20}, // 0x63 'c'
  {0x38,0x44,0x44,0x48,0x7F}, // 0x64 'd'
  {0x38,0x54,0x54,0x54,0x18}, // 0x65 'e'
  {0x08,0x7E,0x09,0x01,0x02}, // 0x66 'f'
  {0x0C,0x52,0x52,0x52,0x3E}, // 0x67 'g'
  {0x7F,0x08,0x04,0x04,0x78}, // 0x68 'h'
  {0x00,0x44,0x7D,0x40,0x00}, // 0x69 'i'
  {0x20,0x40,0x44,0x3D,0x00}, // 0x6A 'j'
  {0x7F,0x10,0x28,0x44,0x00}, // 0x6B 'k'
  {0x00,0x41,0x7F,0x40,0x00}, // 0x6C 'l'
  {0x7C,0x04,0x18,0x04,0x78}, // 0x6D 'm'
  {0x7C,0x08,0x04,0x04,0x78}, // 0x6E 'n'
  {0x38,0x44,0x44,0x44,0x38}, // 0x6F 'o'
  {0x7C,0x14,0x14,0x14,0x08}, // 0x70 'p'
  {0x08,0x14,0x14,0x18,0x7C}, // 0x71 'q'
  {0x7C,0x08,0x04,0x04,0x08}, // 0x72 'r'
  {0x48,0x54,0x54,0x54,0x24}, // 0x73 's'
  {0x04,0x3F,0x44,0x40,0x20}, // 0x74 't'
  {0x3C,0x40,0x40,0x20,0x7C}, // 0x75 'u'
  {0x1C,0x20,0x40,0x20,0x1C}, // 0x76 'v'
  {0x3C,0x40,0x30,0x40,0x3C}, // 0x77 'w'
  {0x44,0x28,0x10,0x28,0x44}, // 0x78 'x'
  {0x0C,0x50,0x50,0x50,0x3C}, // 0x79 'y'
  {0x44,0x64,0x54,0x4C,0x44}, // 0x7A 'z'
  {0x00,0x08,0x36,0x41,0x00}, // 0x7B '{'
  {0x00,0x00,0x7F,0x00,0x00}, // 0x7C '|'
  {0x00,0x41,0x36,0x08,0x00}, // 0x7D '}'
  {0x10,0x08,0x08,0x10,0x08}, // 0x7E '~'
};

// ═══════════════════════════════════════════════════════════════
//  SSD1306 驱动类
// ═══════════════════════════════════════════════════════════════

class SSD1306 {
public:
  static const uint8_t WIDTH  = 128;
  static const uint8_t HEIGHT = 64;
  static const uint16_t BUF_SIZE = (uint16_t)WIDTH * HEIGHT / 8; // 1024 bytes
  static const uint8_t PAGES = HEIGHT / 8;                       // 8 pages

  /**
   * 构造函数
   * @param addr  I2C 7-bit 地址 (0x3C 对应 8-bit 0x78)
   * @param sda   SDA 引脚
   * @param scl   SCL 引脚
   */
  SSD1306(uint8_t addr = 0x3C, int sda = 9, int scl = 10)
    : _addr(addr), _sda(sda), _scl(scl) {
    memset(_buffer, 0, BUF_SIZE);
  }

  // ─── 初始化 & 控制 ────────────────────────────────────

  /** 初始化 I2C 与 SSD1306 */
  bool begin() {
    Wire.begin(_sda, _scl);
    Wire.setClock(100000); // 100kHz 标准模式 (更稳定)
    delay(100);            // 等待 OLED 上电稳定

    // 逐条发送初始化命令
    sendCommand(0xAE);       // 关闭显示

    sendCommand(0xD5);       // 设置时钟分频
    sendCommand(0x80);

    sendCommand(0xA8);       // 设置多路复用率
    sendCommand(0x3F);       // 64-1 = 63

    sendCommand(0xD3);       // 设置显示偏移
    sendCommand(0x00);

    sendCommand(0x40);       // 设置起始行 0

    sendCommand(0x8D);       // 电荷泵设置
    sendCommand(0x14);       // 启用电荷泵

    sendCommand(0x20);       // 设置寻址模式
    sendCommand(0x02);       // 页寻址模式 (最兼容)

    sendCommand(0xA1);       // 段重映射 (左右正常)
    sendCommand(0xC8);       // COM扫描方向 (上下正常)

    sendCommand(0xDA);       // COM引脚配置
    sendCommand(0x12);       // 交替模式, 128x64

    sendCommand(0x81);       // 设置对比度
    sendCommand(0x7F);       // 中等亮度

    sendCommand(0xD9);       // 预充电周期
    sendCommand(0x22);

    sendCommand(0xDB);       // VCOMH电压
    sendCommand(0x20);

    sendCommand(0xA4);       // 显示跟随RAM
    sendCommand(0xA6);       // 正常显示(非反相)
    sendCommand(0xAF);       // 开启显示

    delay(100);

    clear();
    display();
    return true;
  }

  /** 设置对比度 (0-255) */
  void setContrast(uint8_t contrast) {
    sendCommand(0x81);
    sendCommand(contrast);
  }

  /** 反相显示 */
  void invertDisplay(bool invert) {
    sendCommand(invert ? 0xA7 : 0xA6);
  }

  // ─── 帧缓冲区操作 ────────────────────────────────────

  /** 清空帧缓冲区 */
  void clear() {
    memset(_buffer, 0, BUF_SIZE);
  }

  /** 将帧缓冲区刷新到屏幕 (逐页发送, 每页128字节) */
  void display() {
    for (uint8_t page = 0; page < PAGES; page++) {
      // 设置当前页地址
      sendCommand(0xB0 + page);  // 页地址 B0~B7
      sendCommand(0x02);         // 低4位列地址 = 2 (补偿模块偏移)
      sendCommand(0x10);         // 高4位列地址 = 0

      // 该页在缓冲区中的起始位置
      uint16_t offset = (uint16_t)page * WIDTH;

      // 每次发送 16 字节 (共 128/16 = 8 次)
      for (uint8_t col = 0; col < WIDTH; col += 16) {
        Wire.beginTransmission(_addr);
        Wire.write(0x40); // 数据前缀
        for (uint8_t i = 0; i < 16; i++) {
          Wire.write(_buffer[offset + col + i]);
        }
        Wire.endTransmission();
      }
    }
  }

  // ─── 基础绘图 API ─────────────────────────────────────

  /** 画像素 */
  void drawPixel(int16_t x, int16_t y, bool color = true) {
    if (x < 0 || x >= WIDTH || y < 0 || y >= HEIGHT) return;
    uint16_t idx = x + (y / 8) * WIDTH;
    if (color) {
      _buffer[idx] |=  (1 << (y & 7));
    } else {
      _buffer[idx] &= ~(1 << (y & 7));
    }
  }

  /** 画水平线 */
  void drawHLine(int16_t x, int16_t y, int16_t w, bool color = true) {
    for (int16_t i = 0; i < w; i++) drawPixel(x + i, y, color);
  }

  /** 画垂直线 */
  void drawVLine(int16_t x, int16_t y, int16_t h, bool color = true) {
    for (int16_t i = 0; i < h; i++) drawPixel(x, y + i, color);
  }

  /** 画线段 (Bresenham) */
  void drawLine(int16_t x0, int16_t y0, int16_t x1, int16_t y1, bool color = true) {
    int16_t dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
    int16_t dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
    int16_t err = dx + dy, e2;
    for (;;) {
      drawPixel(x0, y0, color);
      if (x0 == x1 && y0 == y1) break;
      e2 = 2 * err;
      if (e2 >= dy) { err += dy; x0 += sx; }
      if (e2 <= dx) { err += dx; y0 += sy; }
    }
  }

  /** 画矩形（边框） */
  void drawRect(int16_t x, int16_t y, int16_t w, int16_t h, bool color = true) {
    drawHLine(x, y, w, color);
    drawHLine(x, y + h - 1, w, color);
    drawVLine(x, y, h, color);
    drawVLine(x + w - 1, y, h, color);
  }

  /** 填充矩形 */
  void fillRect(int16_t x, int16_t y, int16_t w, int16_t h, bool color = true) {
    for (int16_t j = 0; j < h; j++) drawHLine(x, y + j, w, color);
  }

  /** 画圆（Midpoint） */
  void drawCircle(int16_t cx, int16_t cy, int16_t r, bool color = true) {
    int16_t x = r, y = 0, d = 1 - r;
    while (x >= y) {
      drawPixel(cx+x, cy+y, color); drawPixel(cx-x, cy+y, color);
      drawPixel(cx+x, cy-y, color); drawPixel(cx-x, cy-y, color);
      drawPixel(cx+y, cy+x, color); drawPixel(cx-y, cy+x, color);
      drawPixel(cx+y, cy-x, color); drawPixel(cx-y, cy-x, color);
      y++;
      if (d <= 0) d += 2*y + 1;
      else { x--; d += 2*(y-x) + 1; }
    }
  }

  /** 填充圆 */
  void fillCircle(int16_t cx, int16_t cy, int16_t r, bool color = true) {
    for (int16_t y = -r; y <= r; y++) {
      int16_t dx = (int16_t)sqrt(r*r - y*y);
      drawHLine(cx - dx, cy + y, 2*dx + 1, color);
    }
  }

  // ─── 文字绘制 ─────────────────────────────────────────

  /** 绘制单个 ASCII 字符, 返回字符宽度(含间距) */
  int drawChar(int16_t x, int16_t y, char c, bool color = true) {
    if (c < 0x20 || c > 0x7E) c = '?';
    uint8_t idx = c - 0x20;
    for (uint8_t col = 0; col < 5; col++) {
      uint8_t line = pgm_read_byte(&FONT_5x7[idx][col]);
      for (uint8_t row = 0; row < 7; row++) {
        if (line & (1 << row)) {
          drawPixel(x + col, y + row, color);
        }
      }
    }
    return 6; // 5像素宽 + 1像素间距
  }

  /** 绘制 ASCII 字符串 */
  void drawString(int16_t x, int16_t y, const char* str, bool color = true) {
    while (*str) {
      if (*str == '\n') {
        x = 0; y += 8; str++; continue;
      }
      x += drawChar(x, y, *str, color);
      str++;
    }
  }

  /** 获取帧缓冲区指针 */
  uint8_t* getBuffer() { return _buffer; }

private:
  uint8_t _addr;
  int     _sda;
  int     _scl;
  uint8_t _buffer[BUF_SIZE];

  /** 发送命令 */
  void sendCommand(uint8_t cmd) {
    Wire.beginTransmission(_addr);
    Wire.write(0x00); // Co=0, D/C#=0 -> 命令
    Wire.write(cmd);
    Wire.endTransmission();
  }
};
